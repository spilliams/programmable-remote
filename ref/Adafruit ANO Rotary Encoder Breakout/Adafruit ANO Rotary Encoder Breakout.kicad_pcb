# Repository spilliams/programmable-remote

File README.md:

# Programmable Remote

This repo contains all files related to my project to make a programmable infrared remote control.

I'm using this project as a way to get deeper into embedded programming. It should suffice as a companion project while I read Elecia White's _Making Embedded Systems_.

## KiCad design ref/Adafruit ANO Rotary Encoder Breakout/Adafruit ANO Rotary Encoder Breakout.kicad_pcb

Parts:
FID3, FID4: FIDUCIAL_1MM
JP3: HEADER-1X970MIL; 1X09_ROUND_70
U$25, U$27, U$29, U$30: MOUNTINGHOLE2.5; MOUNTINGHOLE_2.5_PLATED
X1: ENCODER_ANO

Connections:
COMA: JP3.3, X1.COM_A (COMA)
COMB: JP3.9, X1.COM_B
ENC_A: JP3.1, X1.A
ENC_B: JP3.2, X1.B
SW1: JP3.4, X1.S1 (1)
SW2: JP3.5, X1.S2
SW3: JP3.6, X1.S3
SW4: JP3.7, X1.S4
SW5: JP3.8, X1.S5

Board: 2 copper layers, 35.6 x 38.1 mm, 10 parts (1 on the bottom side), 9 nets.

Other parts of the board:
U$32: ADAFRUIT_3.5MM
U$33: PCBFEAT-REV-040

## KiCad design ref/Adafruit USB C microlipo charger/Adafruit USB C microlipo charger.kicad_pcb

Board: 2 copper layers, 22.9 x 19.0 mm, 24 parts (2 on the bottom side), 12 nets.

Parts:
C1, C2: 10µF; 0805-NO@1
CN2: JSTPH; JSTPH2
FID1, FID2: FIDUCIAL""; FIDUCIAL_1MM
JP4: 1X05_ROUND_70
LED1: RED; CHIPLED_0805_NOOUTLINE
LED2: GREEN; CHIPLED_0805_NOOUTLINE
R1, R2: 470; 0603-NO
R3: 10K\; 0603-NO
R4: 2.2K; 0603-NO
R5, R6: 5.1K; 0603-NO
SJ1: SOLDERJUMPER_ARROW_NOPASTE
U1: MCP73831T-2ACI/OT; SOT23-5
U$2: ADAFRUIT_2.5MM
U$9, U$10, U$11, U$12: MOUNTINGHOLE2.5; MOUNTINGHOLE_2.5_PLATED
U$13: ADAFRUIT_5MM
U$16: PCBFEAT-REV-040
X2: USB_C_CUSB31-CFM2AX-01-X

Connections:
5V: C1.1, JP4.1, LED1.A, U1.4, X2.A4B9, X2.B4A9
CC1: R6.2, X2.A5
CC2: R5.2, X2.B5
D+: JP4.3, X2.A6, X2.B6
D-: JP4.2, X2.A7, X2.B7
GND: C1.2, C2.2, CN2.1, JP4.4, LED2.C, R3.2, R4.2, R5.1, R6.1, U1.2, X2.A1B12, X2.B1A12
unnamed: LED1.C, R1.1
unnamed: R1.2, R2.2, U1.1
unnamed: R4.1, SJ1.1
unnamed: R3.1, SJ1.2, U1.5
unnamed: LED2.A, R2.1
VBAT: C2.1, CN2.2, JP4.5, U1.3

## KiCad design ref/Adafruit_SharpMemoryDisplay/Adafruit_SharpMemoryDisplay.kicad_pcb

Board: 16 copper layers, 40.0 x 39.0 mm, 23 parts (0 on the bottom side), 17 nets.

Parts:
C1: 0.1µF; _0805
C2, C3: 1µF; _0805
C4, C5: 10µF; _0805
FB1, FB2: _0805
FID1, FID2, FID3: FIDUCIAL""; FIDUCIAL_1MM
IC1: LS013B4DN04; FPC_10PIN_52892-1095
JP1: 1X09_ROUND_70
R1, R2, R3: 10K; _0805
U1: 74HC4050D; SOIC16
U2: MCP1824T-3302E/OT; SOT23-5
U$19: LOGIC_5VREADY_5MM
U$21, U$22, U$27, U$28: MOUNTINGHOLE3.0THIN; MOUNTINGHOLE_3.0_PLATEDTHIN
U$29: ADAFRUIT_5MM

Connections:
3.3V: C3.1, C5.1, FB1.1, IC1.P$7, JP1.2, R1.1, U1.1, U2.5
AGND: C2.2, FB2.2, IC1.P$10
AVDD: C2.1, FB1.2, IC1.P$6
DISP: C1.1, IC1.P$5, U1.12
DISP_5V: JP1.8, R1.2, U1.11
EXTCOMIN: IC1.P$4, U1.10
EXTCOMIN_5V: JP1.9, R2.1, U1.9
EXTMODE: IC1.P$8, U1.15
EXTMODE_5V: JP1.7, R3.2, U1.14
GND: C1.2, C3.2, C4.2, C5.2, FB2.1, IC1.P$9, JP1.3, R2.2, R3.1, U1.8, U2.2
SCLK: IC1.P$1, U1.2
SCLK_5V: JP1.4, U1.3
SCS: IC1.P$3, U1.6
SCS_5V: JP1.6, U1.7
SI: IC1.P$2, U1.4
SI_5V: JP1.5, U1.5
VIN: C4.1, JP1.1, U2.1, U2.3

## Commit log

2024-05-05 every repo needs a readme
2024-05-05 hello, world
2024-05-05 two leds
2024-05-05 read some buttons
2024-05-05 read the encoder too
2024-05-05 fewer breadboard wires
2024-05-07 new breadboard, new wiring
2024-05-24 last commit for epd before i switch. untested?
2024-05-24 no more epd
2024-05-24 wire up the Sharp
2024-05-24 it can repl!
2025-03-20 restructure
2025-03-20 dump
2025-03-20 document
